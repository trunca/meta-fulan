RRECOMMENDS_${PN}_remove_sh4 = " \
	gstplayer \
	gst-ifdsrc \
	"
