OPTIONAL_PACKAGES_remove_sh4 = " \
	dvb-apps \
	wscan \
	gdb \
	gstplayer \
	nodejs \
	smbnetfs \
	"

ENIGMA2_OPTIONAL_remove_sh4 = " \
	enigma2-plugin-extensions-install-gstplayer \
	"
